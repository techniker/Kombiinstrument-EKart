# IAR project kombiinstrument.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: c:\kombiinstrument\lib_src; c:\kombiinstrument\lib_inc; c:\kombiinstrument\user; c:\kombiinstrument\startup
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Kombiinstrument.srec
  ILINK.IlinkOutputFile: Kombiinstrument.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib_inc
    lib_inc/: core_cm3.h fonts.h misc.h stm32f10x.h stm32f10x_can.h stm32f10x_conf.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_it.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h system_stm32f10x.h
  group lib_src
    lib_src/: core_cm3.c misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c
  group startup
    startup/: startup_stm32f10x_md.s
  group user
    user/: config.c config.h display.c display.h holder.c holder.h main.c main.h
